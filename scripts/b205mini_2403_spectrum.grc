options:
  parameters:
    author: GNU Radio
    comment: B205mini spectrum around BLE channel 37 (2402 MHz) / 2403 MHz test center
    description: Capture 4 MS/s at 2403 MHz and display a 2 MHz spectrum.
    generate_options: qt_gui
    id: b205mini_2403_spectrum
    output_language: python
    title: B205mini 2403 MHz Spectrum
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    comment: RF tuning center.
    value: 2.403e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Complex sample rate sent by the B205mini.
    value: 10e6
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 1.5e6
    comment: Display 2 MHz centered at 2403 MHz.
    ctrlpanel: 'True'
    fc: center_freq
    fftsize: '4096'
    grid: 'True'
    label: Power
    legend: 'False'
    name: '"2 MHz spectrum around 2403 MHz"'
    type: complex
    update_time: '0.001'
    wintype: window.WIN_HAMMING
    ymax: '0'
    ymin: '-120'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: 1.5e6
    center_freq0: center_freq
    clock_rate: '0.0'
    comment: B205mini receive input; use RX2 by default.
    dc_offs_enb0: auto
    dev_args: '"type=b200"'
    gain0: '30'
    rx_agc0: Disabled
    samp_rate: samp_rate
    stream_args: '"type=b200"'
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
